Commit message: finish enshu day3

File: mechatrobot/urdf/robot.urdf (robot description, URDF)
Before this commit: robot robot, 4 links, 3 joints
Links:
- link joint_link: geometry visual mesh filename=package://mechatrobot/urdf/my_mesh.stl scale=0.001 0.001 0.001
